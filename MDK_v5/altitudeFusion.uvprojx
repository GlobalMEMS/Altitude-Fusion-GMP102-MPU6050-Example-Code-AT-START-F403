# Keil uVision project altitudeFusion.uvprojx, settings and files
target altitudeFusion (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: AT32F403ZC ArteryTek
  pack: Keil.AT32F4xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403Zx_HD,LIBRARY_VERSION
  c include: ..;..\LibGMEMS;..\LibGMEMS\MPU6050;..\LibGMEMS\GMP102;..\FusionBoard\HARDWARE\GUI;..\FusionBoard\HARDWARE\KEY;..\FusionBoard\HARDWARE\LCD;..\FusionBoard\HARDWARE\MPU6050\eMPL;..\FusionBoard\SYSTEM\delay;..\FusionBoard\SYSTEM\sys;..\FusionBoard\SYSTEM\usart;..\..\..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\CM4\CoreSupport;..\..\..\Libraries\CMSIS\CM4\DeviceSupport;..\..\HyperTerminal_Interrupt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ../: main.c at32f4xx_it.c
  group CMSIS
    ../: system_at32f4xx.c
    ../../../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403zx_hd.s
  group AT32Periph
    ../../../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_gpio.c at32f4xx_rcc.c at32f4xx_usart.c misc.c at32f4xx_i2c.c at32f4xx_tim.c at32f4xx_spi.c
  group LibGMEMS
    ../LibGMEMS/: i2c_gmems.c bus_support.c misc_util.c pSensor_util.c gmems_fusion.c
    ../LibGMEMS/GMP102/: gmp102.c
    ../LibGMEMS/MPU6050/: mpu6050.c
  group FusionBoard
    ../FusionBoard/HARDWARE/LCD/: Lcd_Driver.c
    ../FusionBoard/SYSTEM/delay/: delay.c
    ../FusionBoard/HARDWARE/GUI/: GUI.c
    ../FusionBoard/SYSTEM/usart/: usart.c
    ../FusionBoard/HARDWARE/KEY/: key.c
    ../FusionBoard/HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
